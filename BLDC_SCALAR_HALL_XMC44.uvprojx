# Keil uVision project BLDC_SCALAR_HALL_XMC44.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: XMC4400-F100x512 Infineon
  pack: Infineon.XMC4000_DFP.2.7.1
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x1FFFC000,0x4000) IROM(0x08000000,0x80000) IROM2(0x0C000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLDC_SCALAR_HALL_XMC44_uCProbe.
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\ControlModule;.\Configuration;.\Debug;.\Interrupts;.\Libraries\Newlib;.\MCUInit;.\MidSys
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  link misc: --callgraph
  group Source Group 1
    ./: bldc_scalar_variables_config.c bldc_scalar_user_interface.c main.c
  group Control_Module
    ./ControlModule/: bldc_scalar_control_hall.c bldc_scalar_control_scheme.c bldc_scalar_ramp_generator.c
  group Interrupt
    ./Interrupts/: bldc_scalar_control_loop.c bldc_scalar_ctrap.c bldc_scalar_hall_event.c bldc_scalar_pattern_shadowtx.c bldc_scalar_protection_error.c bldc_scalar_state_machine.c
  group Library
    ./Libraries/Newlib/: syscalls.c
  group MCUINIT
    ./MCUInit/: ccu4.c ccu8.c dac.c gpio.c nvic.c posif.c systick.c vadc.c
  group MIDSys
    ./MidSys/: bldc_scalar_volt_userdef.c bldc_scalar_volt_potentiometer.c bldc_scalar_volt_dcbus.c bldc_scalar_speed_pos_hall.c bldc_scalar_pwm_bc.c bldc_scalar_current_motor.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.0.0, Device:XMClib:CCU4 2.1.8, Device:XMClib:CCU8 2.1.8, Device:XMClib:DAC 2.1.8, Device:XMClib:DMA 2.1.8, Device:XMClib:DSD 2.1.8, Device:XMClib:ERU 2.1.8, Device:XMClib:FCE 2.1.8, Device:XMClib:GPIO 2.1.8, Device:XMClib:HRPWM 2.1.8, Device:XMClib:POSIF 2.1.8, Device:XMClib:SCU 2.1.8, Device:XMClib:VADC 2.1.8
